/*
 * ADC.c
 *
 * Created: 7/05/2024 07:34:02
 *  Author: Javier
 */ 

#include "ADC.h"
#include <avr/io.h>
#include <stdint.h>

void setADC(uint8_t voltaje, uint8_t justificacion, uint8_t canal){
	if(voltaje == 0){
		ADMUX &= ~((1 << REFS0) | (1 << REFS1));
	}
	else if(voltaje == 1){
		ADMUX &= ~(1 << REFS1);
		ADMUX |= (1 << REFS0);
	}
	else{
		ADMUX |= (1 << REFS0) | (1 << REFS1);
	}
	
	
	if(justificacion == 1){
		ADMUX |= (1 << ADLAR);
	}
	else{
		ADMUX &= ~(1 << ADLAR);
	}
	
	ADMUX = (ADMUX & 0xF0) | canal;
}

void controlADC(uint8_t enable, uint8_t trigger, uint8_t interrupcion, uint8_t prescaler){
	if(enable == 1){
		ADCSRA |= (1 << ADEN);
	}
	else{
		ADCSRA &= ~(1 << ADEN);
	}
	
	if(trigger == 1){
		ADCSRA |= (1 << ADATE);
	}
	else{
		ADCSRA &= ~(1 << ADATE);
	}
	
	if(interrupcion == 1){
		ADCSRA |= (1 << ADIE);
	}
	else {
		ADCSRA &= ~(1 << ADIE);
	}
	
	switch (prescaler){
		case 2:
		ADCSRA &= ~((1 << ADPS0) | (1 << ADPS1) | (1 << ADPS2));
		break;
		case 4:
		ADCSRA |= (1 << ADPS1);
		ADCSRA &= ~((1 << ADPS0) | (1 << ADPS2));
		break;
		case 8:
		ADCSRA |= (1 << ADPS0 ) | (1 << ADPS1);
		ADCSRA &= ~(1 << ADPS2);
		break;
		case 16:
		ADCSRA |= (1 << ADPS2);
		ADCSRA &= ~((1 << ADPS0) | (1 << ADPS1));
		break;
		case 32:
		ADCSRA |= (1 << ADPS0 ) | (1 << ADPS2);
		ADCSRA &= ~(1 << ADPS1);
		break;
		case 64:
		ADCSRA |= (1 << ADPS1) | (1 << ADPS2);
		ADCSRA &= ~(1 << ADPS0);
		break;
		case 128:
		ADCSRA |= (1 << ADPS0) | (1 << ADPS1) | (1 << ADPS2);
		break;
		default:
		ADCSRA &= ~((1 << ADPS0) | (1 << ADPS1) | (1 << ADPS2));
	}
}